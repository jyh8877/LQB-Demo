# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\User
  group Hardware
    ./Hardware/: Led.c Seg.c Key.c ul.c ds1302.c onewire.c iic.c uart.c
  group User
    ./: STARTUP.A51
    ./User/: main.c main.h
